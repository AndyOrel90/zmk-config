## config/boards/shields/artsey/Kconfig.defconfig
```kconfig
if SHIELD_ARTSEY_LEFT || SHIELD_ARTSEY_RIGHT

config ZMK_KEYBOARD_NAME
	default "ARTSEY"

endif
```
